# Keil uVision project h7_basic_board_code.uvprojx, settings and files
target h7_basic_board_code (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: h7_basic_board_code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../bsp;../components/modules;../application;../components/algorithm;../components/support;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/RTOS/Template/;../components/modules/DJI_motor_module;../components/modules/CAN_receive;../components/modules/cubemars;../components/modules/Custom_contrllor;../components/modules/Ex_encoder;../components/modules/M4310_module;../components/modules/M8010_motor_module;../components/modules/remote_control;../components/modules/RM_UI;../components/modules/servo;../components/modules/ws2812;../application/chassis;../application/catcher;../application/gimbal;../application/hand;../application/detect_task;../application/referee;../application/usart_measure_task;../application/vofa_uart_task
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application
    ../application/catcher/: catcher_task.c catcher_task_interface.c
    ../application/chassis/: chassis_task.c chassis_task_interface.c
    ../application/gimbal/: gimbal_task.c gimbal_task_interface.c
    ../application/hand/: hand_task.c hand_task_interface.c
    ../application/detect_task/: detect_task.c
    ../application/: motor_timer_ctrl.c general_movement.c
    ../application/referee/: referee.c referee_usart_task.c
    ../application/usart_measure_task/: usart_measure_task.c
    ../application/vofa_uart_task/: vofa_uart_task.c
  group bsp
    ../bsp/: bsp_adc.c bsp_rc.c bsp_led.c bsp_usart.c can_bsp.c bsp_buzzer.c bsp_pwm.c
  group modules
    ../components/modules/CAN_receive/: CAN_receive.c
    ../components/modules/cubemars/: AK_series.c
    ../components/modules/Custom_contrllor/: crc.c Custom_ctrl.c
    ../components/modules/DJI_motor_module/: DJI_motor.c DJI_motor_canbus.c
    ../components/modules/Ex_encoder/: Ex_encoder.c
    ../components/modules/M4310_module/: dm4310_drv.c
    ../components/modules/M8010_motor_module/: M8010_motor.c
    ../components/modules/remote_control/: remote_control.c
    ../components/modules/RM_UI/: ui_g.c ui_interface.c
    ../components/modules/servo/: servo.c
    ../components/modules/ws2812/: ws2812.c
  group support
    ../components/support/: circular_buffer.c CRC8_CRC16.c fifo.c mem_mang4.c angle_process.c Vofa.c
  group algorithm
    ../components/algorithm/: pid.c user_lib.c crc_ccitt.c
software components: CMSIS:CORE 4.3.0
